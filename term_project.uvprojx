# Keil uVision project term_project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: S32K144HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: term_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\RTE\Device\S32K144HAxxxLHx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLHx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c ADC.c ADC.h clocks_and_modes.c clocks_and_modes.h LPUART.c LPUART.h IO_Init.c IO_Init.h IO_keypad.c IO_keypad.h midi.c midi.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0
